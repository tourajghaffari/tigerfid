# IAR project Blocker.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L151F3 STM8L151F3
  General.GenCodeModel: 1
  General.GenDataModel: 0
  General.GenStackSize: 0x300
  General.GenHeapSize: 0x300
  ICCSTM8.CCDefines: STM8L15X_LD
  ICCSTM8.CCDiagSuppress: Pe188,Pe940,Pe177,Pe186
  ICCSTM8.CCIncludePath2: ..; ..\Libraries\STM8L15x_StdPeriph_Driver\inc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: Blocker.bin
  ILINK.IlinkOutputFile: Blocker.out
  ILINK.IlinkIcfFile: lnkstm8l151f3.icf
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenCodeModel: 0
  ICCSTM8.CCDefines: NDEBUG; STM8L15X_LD
configuration Test_Release (STM8, debug)
  as the first configuration, except:
  General.GenCodeModel: 0
  group (top)
    ./: lnkstm8l151f3.icf
  group Include Files
    ../: blocker_services.h i2c_ee.h stm8l15x_it.h
  group Library
    ../Libraries/STM8L15x_StdPeriph_Driver/src/: stm8l15x_adc.c stm8l15x_clk.c stm8l15x_exti.c stm8l15x_gpio.c stm8l15x_i2c.c stm8l15x_itc.c stm8l15x_pwr.c stm8l15x_rtc.c stm8l15x_spi.c
  group Source Files
    ../: blocker_services.c i2c_ee.c main.c stm8l15x_it.c
